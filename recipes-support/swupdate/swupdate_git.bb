require swupdate.inc

SRCREV = "b96b5afab8152caf00090468ec92989d5d31ee44"
